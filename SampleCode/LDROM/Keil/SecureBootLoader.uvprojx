# Keil uVision project SecureBootLoader.uvprojx, settings and files
target SecureBootLoader (6220000::V6.22::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.2
  cpu: IRAM(0x20000000,0xC000) IROM(0x00100000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: secure_boot_loader +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Library\FWUpdate;..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0xC000
  scatter file: .\ldrom.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ../../../Library/StdDriver/src/: clk.c sys.c
    ../../../Library/FWUpdate/: BootIspLib_Keil.lib
  group User
    ../: main.c
